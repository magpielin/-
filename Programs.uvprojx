# Keil uVision project Programs.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Programs +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Libraries\startup;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\hardware;.\Objects;.\using;.\DebugConfig
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./using/: main.c delay.c control.c usart.c timer.c
  group Startup
    ./Libraries/startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Lib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group hardware
    ./hardware/: key.c motor.c CGQ.c led.c
